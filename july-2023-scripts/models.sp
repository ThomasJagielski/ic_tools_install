*
*
*
.lib /home/thomas/actsim_xyce_skywater-pdk/models/sky130.lib.spice tt
