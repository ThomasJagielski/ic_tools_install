*
*
*
.lib /home/thomas/skywater/sky130-xyce/models/sky130.lib.spice tt
